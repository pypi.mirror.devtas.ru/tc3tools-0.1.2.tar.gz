{attribute 'qualified_only'}
VAR_GLOBAL
    MAX_RETRIES : INT := 3;
    TIMEOUT_MS : TIME := T#5000MS;
    DEBUG_MODE : BOOL := FALSE;
END_VAR
