TYPE ST_NestedData :
STRUCT
    bFlag : BOOL;
    nCount : INT;
END_STRUCT
END_TYPE
