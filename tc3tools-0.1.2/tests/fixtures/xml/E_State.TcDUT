{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_State :
(
    IDLE := 0,
    RUNNING := 1,
    PAUSED := 2,
    STOPPED := 3,
    ERROR := 99
);
END_TYPE
